# Keil uVision project media_center.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: media_center
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c osObjects.h Font_6x8_h.h Font_16x24_h.h GLCD.h GLCD_SPI_LPC1700.c KBD.c KBD.h mario sprites.c alien.c alien2.c ship.c
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS:Keil RTX 4.82.0, Compiler:Event Recorder 1.5.1, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
